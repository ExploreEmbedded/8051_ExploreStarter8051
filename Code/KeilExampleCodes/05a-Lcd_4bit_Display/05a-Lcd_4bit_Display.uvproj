# Keil uVision project 05a-Lcd_4bit_Display.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(40000000)
  output: 05a-Lcd_4bit_Display +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: 05a-Lcd_4bit_Display.c
    ../00-libfiles/: gpio.c lcd.c delay.c
