# Keil uVision project 02a-SwitchLed_Example.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78C052 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 02a-SwitchLed_Example +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 02a-SwitchLed_Example.C
